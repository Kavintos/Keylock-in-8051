# Keil uVision project lcd_lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: lcd_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lcd.h lcd.c key.h key.c main.c
